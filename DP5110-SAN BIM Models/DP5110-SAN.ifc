Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-06-12T15:34:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 12 15:34:57 2024 * Host: Administrator * Database: C:\Users\Lenovo\AppData\Local\Temp\e41e3487-6f55-4908-9667-92407d30db14\5ab6983c-e16f-4873-b3d7-98e9c0775706\ifc * Database version: 5507 * Database creation date: Wed Jun 12 15:34:52 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 12 15:34:53 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 12 15:34:53 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: DP5110-SAN, DP5110-SAN:DP5110-SAN:346704
In: Level 1
Type - Material: Stainless Steel
Type - Pset_FurnitureTypeCommon - NominalHeight: 182270 mm; NominalDepth: 36576 mm
Pset_ElementShading - Color: Various
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DolphinRecessedSanitaryBin
Pset_ProductRequirements - Name: DolphinRecessedMountedSanitaryBin_DolphinSolutionsLimited; Category: Furniture
Pset_QuantityTakeOff - Reference: DP5110-SAN
